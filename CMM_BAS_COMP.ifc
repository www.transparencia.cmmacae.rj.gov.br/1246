Properties of the parts of a building model (IFC2X3), part 6 of 6

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (135)
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto pesado - 1.1/4" (cm)
El83 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 440 | 1.1/4" | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 440 cm
El97 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 200 cm
El98 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 150 | 1.1/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 150 cm
El99 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 355 | 1.1/4" | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 355 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 355 cm
El16 | 05. Pavimento Técnico | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 480 | 1.1/4" | 480 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 480 cm
El17 | 05. Pavimento Técnico | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 317.38 | 1.1/4" | 317.375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 317.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 317.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 317.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 317.375 cm

# IfcFlowSegment: Tubo PVC ponta-bolsa (82)
Type - PredefinedType: RIGIDSEGMENT
Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo PVC ponta-bolsa; Rede: Esgoto; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo PVC ponta-bolsa
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 100 mm - 4" (cm)
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 69.2 | 100 mm - 4" | 69.2016
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 775.37 | 100 mm - 4" | 775.371 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1
3 x  | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 1386.86 | 100 mm - 4" | 1386.86 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 95.05 | 100 mm - 4" | 95.0528
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 117.51 | 100 mm - 4" | 117.509
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 674.73 | 100 mm - 4" | 674.731 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | 01. Estacionamento | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 843.33 | 100 mm - 4" | 843.326 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 10.46 | 100 mm - 4" | 10.4566
 | 02. Térreo | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 243.08 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 243.077 cm
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 29.11 | 100 mm - 4" | 29.1081
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 82.4 | 100 mm - 4" | 82.4
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 2.33 | 100 mm - 4" | 2.32977
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 87.43 | 100 mm - 4" | 87.43
 | 02. Térreo | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 45.75 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 45.7502 cm
 | 02. Térreo | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 18.45 | 100 mm - 4" | 18.4514
 | 02. Térreo | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 82.45 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 82.4526 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 20.78 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 20.7843 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 23.84 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 23.8371 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 34.5 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 34.5 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 38.16 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 38.1638 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 28.8 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 28.8 cm
 | 02. Térreo | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 28.37 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 28.3703 cm
 | 02. Térreo | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 522.66 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 522.661 cm
 | 03. Pavimento Superior | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 43.41 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 43.406 cm
 | 03. Pavimento Superior | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 21.15 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 21.1512 cm
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 162.74 | 100 mm - 4" | 162.737
2 x  | 03. Pavimento Superior | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 33.11 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 33.106 cm
 | 03. Pavimento Superior | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 23.19 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 23.1949 cm
 | 03. Pavimento Superior | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 34.03 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 34.0295 cm
3 x  | 03. Pavimento Superior | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 37.6 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 37.6032 cm
 | 03. Pavimento Superior | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 94.61 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 94.6055 cm
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 239.79 | 100 mm - 4" | 239.79
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 300.9 | 100 mm - 4" | 300.9
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.27 | 100 mm - 4" | 23.2733
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 63.26 | 100 mm - 4" | 63.2586
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 17.01 | 100 mm - 4" | 17.0122
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 39.06 | 100 mm - 4" | 39.061
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 11.06 | 100 mm - 4" | 11.0557
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 54.98 | 100 mm - 4" | 54.9839
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 9.36 | 100 mm - 4" | 9.3615
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 44.67 | 100 mm - 4" | 44.6721
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 7.97 | 100 mm - 4" | 7.97
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 87.73 | 100 mm - 4" | 87.7295
 | 03. Pavimento Superior | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 46.91 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 46.9071 cm
 | 03. Pavimento Superior | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 46.21 | 100 mm - 4" | 46.2062
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 94.92 | 100 mm - 4" | 94.9152
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 305.93 | 100 mm - 4" | 305.93
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 166.55 | 100 mm - 4" | 166.547
2 x  | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 26.58 | 100 mm - 4" | 26.5765
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 24.12 | 100 mm - 4" | 24.1195
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 52.49 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 52.4904 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 152.37 | 100 mm - 4" | 152.373
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 66.49 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 66.4911 cm
2 x  | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 32.5 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 32.5024 cm
2 x  | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 30.8 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 30.8024 cm
2 x  | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 83.3 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 83.3 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 27.2 | 100 mm - 4" | 27.1975
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 71.39 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 71.3911 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 41.63 | 100 mm - 4" | 41.6281
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 15.03 | 100 mm - 4" | 15.0256
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 215.94 | 100 mm - 4" | 215.937
 | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 20.42 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 20.4223 cm
 | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 11.54 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 11.539 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 120.18 | 100 mm - 4" | 120.176
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 32.36 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 32.3619 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 35.64 | 100 mm - 4" | 35.6367
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 23.11 | 100 mm - 4" | 23.1143
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 345.47 | 100 mm - 4" | 345.47
 | 04. Cobertura | 597.4 | 3.76 | ø1 1/2" | 0.12 | ø40 | 2 | 41.72 | 40 mm - 1.1/2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta e bolsa soldável - 40 mm: 41.7193 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 133.32 | 100 mm - 4" | 133.321
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 73.64 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 73.6386 cm
 | 04. Cobertura | 595.8 | 4.75 | ø2" | 0.16 | ø50 | 2 | 31.92 | 50 mm - 2" | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo PVC ponta-bolsa c/ virola - 50 mm - 2": 31.9193 cm
 | 04. Cobertura | 594.5 | 9.8 | ø4" | 0.18 | ø100 | 1 | 79.96 | 100 mm - 4" | 79.9649

# IfcFlowSegment: Tubo rígido c/ ponta lisa (5)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 600 cm; Diâmetro interno: 4.75 cm; Diâmetro: ø2"; Espessura: 0.16 cm; Indicação: ø50
Identificação_Elemento - Nome: 50 mm - 2"; Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Rede: Ventilação; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubo rígido c/ ponta lisa; InnerDiameter: 4.75 cm; NominalDiameter: ø2"
Name | In | Inclinação | Comprimento (cm) | PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2" (cm)
 | 01. Estacionamento | 1 | 53.04 | 53.0427
 | 02. Térreo | 1 | 58.5 | 58.5
 | 03. Pavimento Superior | 2 | 338.88 | 338.877
 | 04. Cobertura | 2 | 308.7 | 308.7
 | 05. Pavimento Técnico | 2 | 291.5 | 291.5

# IfcFlowSegment: Tubos - diâmetro interno comercial (194)
Type - PredefinedType: RIGIDSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - Reference: Tubos - diâmetro interno comercial
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | PVC rígido soldável - Tubos - 25 mm (cm)
 | 01. Estacionamento | 2.16 | ø3/4" | 0.17 | ø25 | 7219.52 | 25 mm | Alimentação | 7219.52
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 77 | 25 mm | Água fria | 77
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 70.6 | 25 mm | Água fria | 70.6
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 29.03 | 25 mm | Água fria | 29.0303
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 83.9 | 25 mm | Água fria | 83.9001
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 33.9 | 25 mm | Água fria | 33.9
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 687.8 | 25 mm | Água fria | 687.8
3 x  | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 3.65 | 25 mm | Água fria | 3.65
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 15.04 | 25 mm | Água fria | 15.0449
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 4.9 | 25 mm | Água fria | 4.9
2 x  | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 56.4 | 25 mm | Água fria | 56.4
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 99.77 | 25 mm | Água fria | 99.7694
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 29.9 | 25 mm | Água fria | 29.9
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 3.05 | 25 mm | Água fria | 3.05
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 282.7 | 25 mm | Água fria | 282.702
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 57 | 25 mm | Água fria | 57
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 52.8 | 25 mm | Água fria | 52.8
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 24.3 | 25 mm | Água fria | 24.3
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 3.4 | 25 mm | Água fria | 3.4
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 24.9 | 25 mm | Água fria | 24.9
2 x  | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 26.4 | 25 mm | Água fria | 26.4
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 83.9 | 25 mm | Água fria | 83.9
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 36 | 25 mm | Água fria | 36
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 252.77 | 25 mm | Água fria | 252.769
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 96.4 | 25 mm | Alimentação | 96.4
 | 02. Térreo | 2.16 | ø3/4" | 0.17 | ø25 | 96.4 | 25 mm | Água fria | 96.4
 | 03. Pavimento Superior | 2.78 | ø1" | 0.21 | ø32 | 94.1 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 94.1 cm
 | 03. Pavimento Superior | 2.78 | ø1" | 0.21 | ø32 | 93.1 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 93.1 cm
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 114 | 25 mm | Água fria | 114
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 7 | 25 mm | Água fria | 7.0035
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 53.28 | 25 mm | Água fria | 53.2788
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 107 | 25 mm | Água fria | 107
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 302 | 25 mm | Água fria | 302
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 2 | 25 mm | Água fria | 2
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 149.9 | 25 mm | Água fria | 149.9
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 7.8 | 25 mm | Água fria | 7.80001
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 33.9 | 25 mm | Água fria | 33.9
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 83.9 | 25 mm | Água fria | 83.9
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 12.8 | 25 mm | Água fria | 12.8
5 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 24.3 | 25 mm | Água fria | 24.3
5 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 3.65 | 25 mm | Água fria | 3.65
3 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 99.9 | 25 mm | Água fria | 99.9
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 86 | 25 mm | Água fria | 86
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 47 | 25 mm | Água fria | 47
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 54.3 | 25 mm | Água fria | 54.3
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 3.05 | 25 mm | Água fria | 3.05
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 56.4 | 25 mm | Água fria | 56.4
4 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 4.9 | 25 mm | Água fria | 4.9
7 x  | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 24.9 | 25 mm | Água fria | 24.9
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 36 | 25 mm | Água fria | 36
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 14.9 | 25 mm | Água fria | 14.9
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 320 | 25 mm | Alimentação | 320
 | 03. Pavimento Superior | 2.16 | ø3/4" | 0.17 | ø25 | 10 | 25 mm | Água fria | 10
7 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 3.65 | 25 mm | Água fria | 3.65
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 514.9 | 25 mm | Água fria | 514.9
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 36 | 25 mm | Água fria | 36
4 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 86 | 25 mm | Água fria | 86
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 14.9 | 25 mm | Água fria | 14.9
5 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 24.3 | 25 mm | Água fria | 24.3
4 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 47 | 25 mm | Água fria | 47
3 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 24.9 | 25 mm | Água fria | 24.9
2 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 54.3 | 25 mm | Água fria | 54.3
4 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 3.05 | 25 mm | Água fria | 3.05
6 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 56.4 | 25 mm | Água fria | 56.4
5 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 4.9 | 25 mm | Água fria | 4.9
2 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 99.9 | 25 mm | Água fria | 99.9
3 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 33.9 | 25 mm | Água fria | 33.9
2 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 57 | 25 mm | Água fria | 57
2 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 27 | 25 mm | Água fria | 27
4 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 9.9 | 25 mm | Água fria | 9.9
2 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 327.8 | 25 mm | Água fria | 327.8
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 52.8 | 25 mm | Água fria | 52.8
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 3.4 | 25 mm | Água fria | 3.4
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 54.9 | 25 mm | Água fria | 54.9
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 1.55 | 25 mm | Água fria | 1.55
3 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 94.9 | 25 mm | Água fria | 94.9
3 x  | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 26.4 | 25 mm | Água fria | 26.4
 | 04. Cobertura | 2.78 | ø1" | 0.21 | ø32 | 67.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 67.9 cm
 | 04. Cobertura | 2.78 | ø1" | 0.21 | ø32 | 217.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 217.9 cm
 | 04. Cobertura | 2.78 | ø1" | 0.21 | ø32 | 96.9 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 96.9 cm
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 320 | 25 mm | Alimentação | 320
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 316.4 | 25 mm | Água fria | 316.4
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 110.4 | 25 mm | Água fria | 110.4
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | -0.2 | 25 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 329.9 | 25 mm | Água fria | 329.9
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 2 | 25 mm | Água fria | 2
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 392 | 25 mm | Água fria | 392
 | 04. Cobertura | 2.16 | ø3/4" | 0.17 | ø25 | 44.9 | 25 mm | Água fria | 44.9
 | 05. Pavimento Técnico | 4.4 | ø1 1/2" | 0.3 | ø50 | 67.49 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Adapt sold c/ flange fixo p cx. d´água - 50 mm - 1.1/2": 1; PVC rígido soldável - Tubos - 50 mm: 67.4853 cm
 | 05. Pavimento Técnico | 4.4 | ø1 1/2" | 0.3 | ø50 | 17 | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 17 cm
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 31.48 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 31.48 cm
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 30.11 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 30.1118 cm
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 32.92 | 25 mm | Água fria | 32.9227
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 79.35 | 25 mm | Água fria | 79.3469
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 25.58 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 25.58 cm
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 41.98 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 41.9816 cm
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 14.1 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 14.1 cm
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 296.4 | 25 mm | Alimentação | 296.4
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 43.9 | 25 mm | Alimentação | 43.9044
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 181.64 | 25 mm | Alimentação | 181.639
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 63.6 | 25 mm | Água fria | 63.6
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 292.8 | 25 mm | Água fria | 292.8
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 93.88 | 25 mm | Alimentação | 93.8822
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 12.06 | 25 mm | Alimentação | 12.0588
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 234.12 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 234.115 cm
2 x  | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 39.7 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 39.7 cm
 | 05. Pavimento Técnico | 2.16 | ø3/4" | 0.17 | ø25 | 167.8 | 25 mm | Alimentação | 167.8
 | 05. Pavimento Técnico | 2.78 | ø1" | 0.21 | ø32 | 60.09 | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 32 mm: 60.0873 cm; PVC rígido soldável - Adapt sold c/ flange fixo p cx. d´água - 32 mm - 1": 1

# IfcFlowStorageDevice: Caixa d'água, RCi1
In: 05. Pavimento Técnico
AltoQi_Builder - Volume efetivo (l): 2000; Altura: 110.6 cm; Diâmetro: 182.15 cm; Indicação: 2000L; Posição: Direta; % do volume do reservatório: 100; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 0.22; Volume útil estimado (m³): 0.22; Volume (m³): 2
Identificação_Elemento - Aplicação: Reservatório cilíndrico; Descrição: Reservatório 2000L; Nome: 2000L; Classe: Reservatório cilíndrico; Tipo: Caixa d'água; Rede: Água fria
Pset_TankTypeCommon - Reference: Caixa d'água; NominalCapacity: 2; NominalDepht: 110.6 cm; NominalLenghtOrDiameter: 182.15 cm
AltoQi_QiBuilder-Itens_Associados - Reservatório cilíndrico - Polietileno - 2000 L: 1

# IfcFlowTerminal: Bebedouro (3)
In: 04. Cobertura
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Bebedouro; Nome: 40mm; Classe: PVC Esgoto; Tipo: Bebedouro; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Bebedouro
Name
 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
2 x 

# IfcFlowTerminal: Caixa Sifonada (9)
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Caixa sifonada; Descrição: Caixa Sifonada; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixa Sifonada
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1
Name | In | Comprimento (cm) | Diâmetro (cm) | Indicação = Nome | PVC Acessórios - Caixa sifonada - 150x150x50
2 x  | 02. Térreo | 15.5 | 15 | 150x150x50 | 1
4 x  | 03. Pavimento Superior | 15.5 | 15 | 150x150x50 | 1
 | 04. Cobertura | 10 | 10.1 | 100x100x50 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 100x100x50: 1
2 x  | 04. Cobertura | 15.5 | 15 | 150x150x50 | 1

# IfcFlowTerminal: Caixas Inspeção Esgoto Sifonada (4)
In: 01. Estacionamento
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CES- 60 x 60 cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa de alvenaria; Descrição: Caixas Inspeção Esgoto Sifonada; Nome: CES- 60 x 60 cm; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Sifonada; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Caixas Inspeção Esgoto Sifonada
AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção de esgoto sifonada - CES- 60x60 cm: 1

# IfcFlowTerminal: Ducha Higiênica com Joelho de 90º (10)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: DH; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Ducha Higiênica; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Ducha Higiênica com Joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Ducha Higiênica com Joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Ducha higiênica - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | 02. Térreo
4 x  | 03. Pavimento Superior
5 x  | 04. Cobertura

# IfcFlowTerminal: Lavatório com joelho de 90º (10)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Lavatório com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | 02. Térreo
4 x  | 03. Pavimento Superior
5 x  | 04. Cobertura

# IfcFlowTerminal: Lavatório de Uso Geral (30)
Type - PredefinedType: WASHHANDBASIN
AltoQi_Builder - Indicação: 40mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Lavatório de Uso Geral; Nome: 40mm; Classe: PVC Esgoto; Tipo: Lavatório de Uso Geral; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Lavatório de Uso Geral
Name | In
2 x  | 02. Térreo
 | 02. Térreo | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
8 x  | 03. Pavimento Superior
4 x  | 03. Pavimento Superior | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
10 x  | 04. Cobertura
5 x  | 04. Cobertura | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcFlowTerminal: Luminárias embutir (148)
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Comprimento: 17.5 cm; Largura: 17.5 cm; Profundidade: 8 cm; Indicação: Lum; Posição: Teto
AltoQi_Builder-Ponto1 - Fator de potência (%): 50; Fluxo luminoso para tensão 127V: 2400 lm; Fluxo luminoso para tensão 12V: 0 lm; Fluxo luminoso para tensão 220V: 2400 lm; Número de lâmpadas: 1; Potência (W): 30; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A2 (Direta); Tipo de ponto: Lâmpada; Requer aterramento: Não
Identificação_Elemento - Aplicação: Caixa; Descrição: Luminária LED 30W; Nome: Ledvance Insert 30W; Classe: Lâmpadas Led; Tipo: Luminárias embutir; Rede: Elétrica
Pset_LightFixtureTypeCommon - Reference: Luminárias embutir
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon-Ponto1 - HasProtectiveEarth: Não
AltoQi_QiBuilder-Itens_Associados - Luminária e acessórios - Luminária Led Embutir - Ledvance Insert 30W: 1
Name | In | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1
26 x  | 02. Térreo | 5 - Iluminação do Salão Principal | g | 02. Térreo | QD1
 | 02. Térreo | 6 - Iluminação da Entrada de Serviço + Escada 2 | h | 02. Térreo | QD1
 | 02. Térreo | 6 - Iluminação da Entrada de Serviço + Escada 2 | i | 02. Térreo | QD1
 | 02. Térreo | 3 - Iluminação da Sala de Energia + Escada 1 + DML | Nenhum | 02. Térreo | QD1
2 x  | 02. Térreo | 1 - Iluminação da Área de Serviço + Jardim | a | 02. Térreo | QD1
6 x  | 02. Térreo | 2 - Iluminação da Sala de Manutenção + Banheiro Térreo | m | 02. Térreo | QD1
 | 02. Térreo | 2 - Iluminação da Sala de Manutenção + Banheiro Térreo | d | 02. Térreo | QD1
4 x  | 02. Térreo | 3 - Iluminação da Sala de Energia + Escada 1 + DML | k | 02. Térreo | QD1
4 x  | 02. Térreo | 4 - Iluminação do Hall | f | 02. Térreo | QD1
 | 02. Térreo | 3 - Iluminação da Sala de Energia + Escada 1 + DML | l | 02. Térreo | QD1
2 x  | 03. Pavimento Superior | 5 - Iluminação da Escada 2 | a | 03. Pavimento Superior | QD2
27 x  | 03. Pavimento Superior | 4 - Iluminação do Salão | e | 03. Pavimento Superior | QD2
2 x  | 03. Pavimento Superior | 3 - Iluminação dos Banheiros | f | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 3 - Iluminação dos Banheiros | j | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 3 - Iluminação dos Banheiros | i | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 3 - Iluminação dos Banheiros | h | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 3 - Iluminação dos Banheiros | g | 03. Pavimento Superior | QD2
6 x  | 03. Pavimento Superior | 2 - Iluminação do Hall e da Escada 1 | c | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 2 - Iluminação do Hall e da Escada 1 | d | 03. Pavimento Superior | QD2
8 x  | 03. Pavimento Superior | 1 - Iluminação da Sala | b | 03. Pavimento Superior | QD2
8 x  | 04. Cobertura | 1 - Iluminação da Sala | b | 04. Cobertura | QD3
 | 04. Cobertura | 2 - Iluminação do Hall e da Escada 1 | d | 04. Cobertura | QD3
3 x  | 04. Cobertura | 3 - Iluminação dos Banheiros | l | 04. Cobertura | QD3
3 x  | 04. Cobertura | 3 - Iluminação dos Banheiros | m | 04. Cobertura | QD3
 | 04. Cobertura | 3 - Iluminação dos Banheiros | n | 04. Cobertura | QD3
2 x  | 04. Cobertura | 3 - Iluminação dos Banheiros | o | 04. Cobertura | QD3
20 x  | 04. Cobertura | 4 - Iluminação do Salão | e | 04. Cobertura | QD3
6 x  | 04. Cobertura | 2 - Iluminação do Hall e da Escada 1 | c | 04. Cobertura | QD3
2 x  | 04. Cobertura | 5 - Iluminação da Área Descoberta e Escada 2 | a | 04. Cobertura | QD3
5 x  | 05. Pavimento Técnico | 1 - Iluminação | p | 05. Pavimento Técnico | QD4

# IfcFlowTerminal: Pia de Cozinha Industrial - Preparação (3)
In: 04. Cobertura
Type - PredefinedType: SINK
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Pia de Cozinha Industrial - Preparação com Sifão; Nome: 50mm; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Preparação; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Pia de Cozinha Industrial - Preparação
Name
2 x 
 | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão p/ pia - 1" x 50 mm: 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 3; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm

# IfcFlowTerminal: Pia de cozinha com joelho de 90º (3)
Type - PredefinedType: SINK
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Pia de cozinha com joelho de 90º; Nome: 25 mm - 1/2"; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Pia de cozinha com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25 mm - 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | 03. Pavimento Superior
2 x  | 04. Cobertura

# IfcFlowTerminal: Ponto de luz (12)
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Alta
AltoQi_Builder-Ponto1 - Fator de potência (%): 100; Fluxo luminoso para tensão 12V: 0 lm; Número de lâmpadas: 1; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Ponto de luz; Rede: Elétrica
Pset_LightFixtureTypeCommon - Reference: Ponto de luz
Pset_LightFixtureTypeCommon-Ponto1 - NumberOfSource: 1
Pset_ElectricalDeviceCommon-Ponto1 - HasProtectiveEarth: Sim
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa de Luz 4"x2" - 4"x 2": 1
Name | In | Fluxo luminoso para tensão 127V (lm) = Fluxo luminoso para tensão 220V (lm) | Potência (W) | Descrição | Nome | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1
 | 02. Térreo | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 3 - Iluminação da Sala de Energia + Escada 1 + DML | Nenhum | 02. Térreo | QD1
2 x  | 02. Térreo | 1680 | 24 | Ponto genérico de luz 24W | 24 W (parede) | 1 - Iluminação da Área de Serviço + Jardim | b | 02. Térreo | QD1
 | 02. Térreo | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 6 - Iluminação da Entrada de Serviço + Escada 2 | i | 02. Térreo | QD1
 | 03. Pavimento Superior | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 5 - Iluminação da Escada 2 | a | 03. Pavimento Superior | QD2
 | 03. Pavimento Superior | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 2 - Iluminação do Hall e da Escada 1 | d | 03. Pavimento Superior | QD2
 | 04. Cobertura | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 2 - Iluminação do Hall e da Escada 1 | d | 04. Cobertura | QD3
 | 04. Cobertura | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 5 - Iluminação da Área Descoberta e Escada 2 | a | 04. Cobertura | QD3
4 x  | 04. Cobertura | 4200 | 35 | Ponto genérico de luz 35W | 35 W (parede) | 5 - Iluminação da Área Descoberta e Escada 2 | k | 04. Cobertura | QD3

# IfcFlowTerminal: Saídas livres
In: 04. Cobertura
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0; Indicação: Saída; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Saídas livres; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Saídas livres; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Saídas livres
AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento

# IfcFlowTerminal: Tanque de Lavar Roupas DN 40mm (6)
In: 02. Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 40mm- J90º parede; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Tanque de Lavar Roupas DN 40mm; Nome: 40mm- J90º parede; Classe: PVC Esgoto; Tipo: Tanque de Lavar Roupas DN 40mm; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de Lavar Roupas DN 40mm
Name
4 x 
2 x  | AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ tanque - 1.1/2" - 2": 1; PVC Acessórios - Válvula p/ tanque - 1 1/2": 1; PVC Esgoto - Joelho 90 - 40 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 40 cm

# IfcFlowTerminal: Tanque de lavar com joelho de 90º (2)
In: 02. Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.25; Indicação: TLR; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Tanque de lavar com joelho de 90º; Nome: 25 mm - 3/4"; Classe: PVC rígido soldável; Tipo: Tanque de lavar com joelho de 90º; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Tanque de lavar com joelho de 90º
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Tanque de Lavar - 25mmx 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcFlowTerminal: Tanques sépticos, Tanque séptico -1
In: 01. Estacionamento
Type - PredefinedType: FLOORWASTE
AltoQi_Builder - Posição: Direta; Intervalo entre limpezas: 2 anos; Número de câmaras: Câmara única; Contribuição de esgoto (L/dia): 650; Contribuição de lodo (L/dia): 5; Taxa de acumul. do lodo (dias/intervalo): 105; Tempo de detenção (dia): 1; Volume útil estimado (m³): 2.175; Comprimento: 200 cm; Largura: 100 cm; Profundidade útil: 120 cm; Volume (m³): 2.4
Identificação_Elemento - Aplicação: Tanque séptico; Nome: Tanque séptico - concreto; Classe: Unidades de tratamento; Tipo: Tanques sépticos; Rede: Esgoto
Pset_WasteTerminalTypeCommon - Reference: Tanques sépticos
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 120.4 cm; Unidades de tratamento - Alça - Ferro: 1; Unidades de tratamento - Concreto - Concreto: 1.68 m3; Unidades de tratamento - Tampa - Hermética: 1

# IfcFlowTerminal: Torneira de Jardim com joelho 90°
In: 02. Térreo
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Vazão de projeto (l/s): 0.2; Indicação: TJ; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Torneira de Jardim; Nome: 25 mm x 1/2"; Classe: PVC rígido soldável; Tipo: Torneira de Jardim com joelho 90°; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Torneira de Jardim com joelho 90°
AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Jardim - 25 mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcFlowTerminal: Vaso Sanitário c/ J90º (10)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Aparelho sanitário; Descrição: Vaso Sanitário c/ J90º; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ J90º; Rede: Esgoto
Pset_SanitaryTerminalTypeCommon - Reference: Vaso Sanitário c/ J90º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Vedação p/ saída de vaso sanitário - 100 mm: 1
Name | In
 | 02. Térreo
4 x  | 03. Pavimento Superior
5 x  | 04. Cobertura

# IfcFlowTerminal: Vaso sanitário com caixa acoplada (10)
Type - PredefinedType: WCSEAT
AltoQi_Builder - Vazão de projeto (l/s): 0.15; Indicação: VS; Posição: Direta
Identificação_Elemento - Aplicação: Peça de utilização; Descrição: Vaso sanitário com caixa acoplada; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Vaso sanitário com caixa acoplada; Rede: Água fria
Pset_SanitaryTerminalTypeCommon - Reference: Vaso sanitário com caixa acoplada
AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário c/ cx. acoplada - 1/2": 1; PVC Acessórios - Engate flexível cobre cromado com canopla - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name | In
 | 02. Térreo
4 x  | 03. Pavimento Superior
5 x  | 04. Cobertura

# IfcFlowTerminal: Válvula admissora de ar, CV-1
In: 05. Pavimento Técnico
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: VAA; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Válvula admissora de ar; Nome: 50 mm; Classe: PVC Esgoto; Tipo: Válvula admissora de ar; Rede: Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Válvula admissora de ar - 50 mm: 1
