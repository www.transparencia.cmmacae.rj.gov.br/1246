Properties of the parts of a building model (IFC2X3), part 5 of 6

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (135)
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto pesado - 1.1/4" (cm)
El180 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 520 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 1300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Preto: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 1040 cm
El181 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 1200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 1200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 900 cm
El182 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 1200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 1200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 900 cm
El183 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 900 cm
El184 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 900 cm
El185 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 900 cm
El20 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 300 cm
El21 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 300 cm
El22 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 300 cm
El23 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 300 | 1.1/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 300 cm
El24 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 220 | 1.1/4" | 220
El25 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 240 cm
El26 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 515 | 1.1/4" | 515 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 515 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 515 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 515 cm
El27 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 190 cm
El28 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 180 | 1.1/4" | 180
El29 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 140 | 1.1/4" | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 140 cm
El30 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 235 | 1.1/4" | 235 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 235 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 235 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 235 cm
El31 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 220 | 1.1/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 220 cm
El32 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 190 cm
El33 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Preto: 190 cm
El34 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 335 | 1.1/4" | 335 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 335 cm
El35 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 590 | 1.1/4" | 590 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 590 cm
El36 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm
El37 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | 190
El38 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 240 cm
El39 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Preto: 260 cm
El40 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" | 320 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Preto: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 640 cm
El41 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Preto: 160 cm
El42 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 260 cm
El43 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El44 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El45 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El46 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El47 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El48 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El49 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El50 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El51 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El52 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El53 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260
El54 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Amarelo: 780 cm
El55 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 345 | 1.1/4" | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 345 cm
El56 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 325 | 1.1/4" | 325 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 325 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 325 cm
El64 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 290 cm
El65 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 310 | 1.1/4" | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 310 cm
El66 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 290 cm
El67 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 290 cm
El68 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 310 | 1.1/4" | 310 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 310 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 310 cm
El69 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 290 | 1.1/4" | 290 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 290 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 290 cm
El82 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 295 | 1.1/4" | 295 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 295 cm
El83 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 405 | 1.1/4" | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 810 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 405 cm
El84 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 200 cm
El85 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 60 | 1.1/4" | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 60 cm
El86 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 130 | 1.1/4" | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 130 cm
El87 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 130 | 1.1/4" | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 130 cm
El88 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 195 | 1.1/4" | 195 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 195 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 195 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 195 cm
El9 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 220 | 1.1/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 220 cm
El90 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200
El91 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 315 | 1.1/4" | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 630 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 315 cm
El92 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 110 | 1.1/4" | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 110 cm
El93 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 365 | 1.1/4" | 365 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 365 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 365 cm
El94 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 80 | 1.1/4" | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 80 cm
El95 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 405 | 1.1/4" | 405 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 405 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 405 cm
El96 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 415 | 1.1/4" | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 415 cm
El97 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 160 cm
El98 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 110 | 1.1/4" | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 110 cm
El163 | 03. Pavimento Superior | 5 | ø2" | 0.63 | ø2" | 360 | 2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 360 cm; Eletroduto PVC flexível - Eletroduto pesado - 2": 720 cm
El164 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 180 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 180 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 360 cm
El21 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 160 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 1760 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde-amarelo: 160 cm
El22 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 190 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1900 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 2090 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde-amarelo: 190 cm
El23 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 160 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 1760 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde-amarelo: 160 cm
El24 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 160 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 1760 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde-amarelo: 160 cm
El25 | 03. Pavimento Superior | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 260 | 1.1/4" | 520 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 520 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 2340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 2860 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 780 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 520 cm
El26 | 03. Pavimento Superior | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 340 | 1.1/4" | 680 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 3060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 3740 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 680 cm
El27 | 03. Pavimento Superior | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 340 | 1.1/4" | 680 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 3060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 3740 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 680 cm
El28 | 03. Pavimento Superior | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 340 | 1.1/4" | 680 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 3060 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 3400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Amarelo: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 340 cm
El6 | 03. Pavimento Superior | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1057.2 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 2114.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 1057.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 3171.6 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 2114.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 1057.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 1057.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 4228.8 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 12686.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 12686.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 1057.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 4228.8 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde-amarelo: 1057.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Vermelho: 1057.2 cm
El100 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 340 | 1.1/4" | 340 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 340 cm
El101 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 70 | 1.1/4" | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 70 cm
El102 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 70 | 1.1/4" | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 70 cm
El103 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 375 | 1.1/4" | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 375 cm
El104 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 250 | 1.1/4" | 250 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 250 cm
El105 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 200 cm
El119 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 170 | 1.1/4" | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 170 cm
El122 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 180 | 1.1/4" | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 180 cm
El14 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 535 | 1.1/4" | 535 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 535 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 535 cm
El144 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 70 | 1.1/4" | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 70 cm
El145 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 165 | 1.1/4" | 165 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 165 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 165 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 165 cm
El15 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 210 cm
El155 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 305 | 1.1/4" | 305 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 305 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 305 cm
El157 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 150 | 1.1/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 150 cm
El158 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 240 cm
El159 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 280 | 1.1/4" | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 280 cm
El164 | 04. Cobertura | 5 | ø2" | 0.63 | ø2" | 10 | 2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 10 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 10 cm
El165 | 04. Cobertura | 5 | ø2" | 0.63 | ø2" | 420 | 2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 420 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 420 cm
El165 | 04. Cobertura | 5 | ø2" | 0.63 | ø2" | 800 | 2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 800 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 800 cm
El165 | 04. Cobertura | 5 | ø2" | 0.63 | ø2" | 610 | 2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 610 cm
El166 | 04. Cobertura | 5 | ø2" | 0.63 | ø2" | 300 | 2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 2": 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm
El167 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210
El168 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210
El169 | 04. Cobertura | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 1140 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 1140 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 1140 cm
El170 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 610 | 1.1/4" | 610 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 610 cm
El250 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 360 | 1.1/4" | 720 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 360 cm
El251 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 150 | 1.1/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 150 cm
El36 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 190 | 1.1/4" | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 190 cm
El37 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 555 | 1.1/4" | 555 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 555 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 555 cm
El38 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 270 | 1.1/4" | 270 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 270 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 270 cm
El39 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 200 cm
El4 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 402.63 | 1.1/4" | 402.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 402.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 402.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 402.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 402.625 cm
El40 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 210 cm
El41 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 210 cm
El42 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 200 cm
El43 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 210 cm
El5 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 627.63 | 1.1/4" | 627.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 627.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 627.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 627.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 627.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 627.625 cm
El62 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 315 | 1.1/4" | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 315 cm
El7 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 377.63 | 1.1/4" | 377.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 377.625 cm
El8 | 04. Cobertura | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 297.63 | 1.1/4" | 297.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 297.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 297.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 297.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 297.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 297.625 cm
