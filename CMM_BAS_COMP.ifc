Properties of the parts of a building model (IFC2X3), part 1 of 6

# File
Description: IFC2X3
Time: 2025-07-01T16:04:46
Made in: IfcPlusPlus

# IfcBuildingStorey (5)
Name | LongName | Elevation (cm)
01. Estacionamento | 01. Estacionamento | 0
02. Térreo | 02. Térreo | 80
03. Pavimento Superior | 03. Pavimento Superior | 400
04. Cobertura | 04. Cobertura | 720
05. Pavimento Técnico | 05. Pavimento Técnico | 1020

# IfcDistributionFlowElement: Filtros, Filtro anaeróbio -1
In: 01. Estacionamento
AltoQi_Builder - Posição: Direta; Altura do vão livre: 30 cm; Contribuição de esgoto (L/dia): 650; Tempo de detenção (dia): 1; Volume útil estimado (m³): 1.04; Altura total do leito: 120 cm; Comprimento: 125 cm; Largura: 80 cm; Volume (m³): 1.2
Identificação_Elemento - Aplicação: Filtro anaeróbio; Nome: Filtro anaeróbio - concreto; Classe: Unidades de tratamento; Tipo: Filtros; Rede: Esgoto
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 250 cm; Unidades de tratamento - Brita - nº4: 1.2 m3; Unidades de tratamento - Concreto - Concreto: 0.06765 m3

# IfcDistributionFlowElement: Sumidouros, Sumidouro -1
In: 01. Estacionamento
AltoQi_Builder - Posição: Direta; Altura da camada de brita: 30 cm; Taxa de aplicação diária (m³/m².dia): 0.13; Taxa de percolação (min/m): 100; Contribuição de esgoto (L/dia): 0; Altura: 150 cm
Identificação_Elemento - Aplicação: Sumidouro; Nome: Circular; Classe: Unidades de tratamento; Tipo: Sumidouros; Rede: Esgoto
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15 cm; Unidades de tratamento - Argamassa - Argamassa: 0.067858 m3; Unidades de tratamento - Brita - nº3: 0.021206 m3; Unidades de tratamento - Tijolo - Furado: 34

# IfcFlowController: Alimentador Predial
In: 01. Estacionamento
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: Com tubo de PVC rígido-3/4"; Posição: Direta
Identificação_Elemento - Aplicação: Alimentador predial; Descrição: Alimentador Predial; Nome: Com tubo de PVC rígido-3/4"; Classe: PVC rígido soldável; Tipo: Alimentador Predial; Rede: Alimentação
Pset_FlowMeterTypeCommon - Reference: Alimentador Predial
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de esfera - 3/4": 1; PVC misto soldável - Colar de tomada em PVC - 3/4": 1; PVC misto soldável - Joelho 90 soldável c/ rosca - 25 mm - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 1

# IfcFlowController: Ancoragem em pontalete - Medição trifásica em parede - Demanda de 24 à 75KVA, AL1
In: 02. Térreo
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 30 cm; Largura: 10 cm; Profundidade: 30 cm; Indicação: Des. 33; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Tensão: 220/127 V
Identificação_Elemento - Aplicação: Entrada de serviço; Descrição: Entrada de serviço aérea; Nome: Demanda de 65 à 75KVA; Classe: Entrada de serviço - ENEL RJ; Tipo: Ancoragem em pontalete - Medição trifásica em parede - Demanda de 24 à 75KVA; Rede: Elétrica
Pset_FlowMeterTypeCommon - Reference: Ancoragem em pontalete - Medição trifásica em parede - Demanda de 24 à 75KVA
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 125 A; NumberOfPoles: 3
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Arruela zamak - 1/2": 4; Acessórios p/ eletrodutos - Arruela zamak - 2.1/2": 4; Acessórios p/ eletrodutos - Bucha zamak - 1/2": 4; Acessórios p/ eletrodutos - Bucha zamak - 2.1/2": 4; Acessórios p/ eletrodutos - Luva PVC rosca - 1/2": 4; Acessórios p/ eletrodutos - Luva PVC rosca - 2.1/2": 4; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 1/2": 150 cm; Eletroduto PVC rosca - Eletroduto, vara 3,0m - 2.1/2": 400 cm; Material p/ entrada serviço - Abraçadeira de nylon - 203mm: 4; Material p/ entrada serviço - Alça pré-formada de distribuição - para condutor 95mm²: 3; Material p/ entrada serviço - Armação secundária aço laminado - 1 haste de 150mm: 1; Material p/ entrada serviço - Bucha plástica - S 8: 2; Material p/ entrada serviço - Cabo cobre nu - Seção 35mm2: 2; Material p/ entrada serviço - Caixa inspeção de aterramento - caixa de PVC: 1; Material p/ entrada serviço - Chumbador de aço - 16mmx110mm - c/ porca e arruela: 1; Material p/ entrada serviço - Conector tipo cunha - Para condutor de 50/35mm²: 1; Material p/ entrada serviço - Haste de aterramento galvanizada - 2000mm: 1; Material p/ entrada serviço - Identificador - de fase: 6; Material p/ entrada serviço - Isolador roldana 600V - Porcelana vidrada: 1; Material p/ entrada serviço - Parafuso auto-atarraxante - soberba - 6,3x38mm: 3; Material p/ entrada serviço - Parafuso cabeça quadrada - 125x80x16mm: 1; Material p/ entrada serviço - Parafuso de cabeça limão - c/ fenda 3/16x1'' c/porca e arruela: 1; Material p/ entrada serviço - Parafuso de cabeça limão - c/ fenda 3/16x3/8'' c/porca e arruela: 2; Material p/ entrada serviço - Parafuso de segurança - Lacre caixa: 1; Material p/ entrada serviço - Parafuso tipo fenda, cabeça plana escariada, bicromatizado - 5,0x50mm para bucha S 8: 2; Material p/ entrada serviço - Prensa- cabo rosqueável - para furo de 28mm e cabo de 15 a 22mm: 1; Material p/ entrada serviço - Selo plástico - Segurança: 2

# IfcFlowController: Registro bruto gaveta ABNT c/PVC soldável
In: 05. Pavimento Técnico
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro bruto gaveta ABNT c/PVC soldável; Nome: 1"; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta ABNT c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro bruto gaveta ABNT c/PVC soldável
AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta bruto ABNT - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2

# IfcFlowController: Registro de gaveta c/canopla cromada c/PVC soldável (12)
Type - PredefinedType: ISOLATING
AltoQi_Builder - Indicação: RG; Posição: Direta
Identificação_Elemento - Aplicação: Registro; Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável; Rede: Água fria
Pset_ValveTypeCommon - Reference: Registro de gaveta c/canopla cromada c/PVC soldável
Name | In | Nome | Metais - Registro de gaveta c/ canopla cromada - 3/4" | PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4"
2 x  | 02. Térreo | 3/4" | 1 | 2
5 x  | 03. Pavimento Superior | 3/4" | 1 | 2
4 x  | 04. Cobertura | 3/4" | 1 | 2
 | 05. Pavimento Técnico | 1" | AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 32 mm - 1": 2

# IfcFlowFitting: Alvenaria - piso (11)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 30 cm; Largura: 30 cm; Profundidade: 30 cm; Indicação: 300x300x300; Posição: Piso
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir no piso; Nome: 300x300x300 mm; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Alvenaria - piso
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Alvenaria - 300x300x300mm: 1; Caixa de passagem - embutir - Alvenaria - Tampa 300x300x50mm: 1
Name | In
CX1 | 02. Térreo
CX2 | 02. Térreo
CX3 | 02. Térreo
CX4 | 02. Térreo
CX5 | 02. Térreo
CX6 | 02. Térreo
CX7 | 02. Térreo
CX8 | 02. Térreo
CX1 | 03. Pavimento Superior
CX1 | 04. Cobertura
CX1 | 05. Pavimento Técnico

# IfcFlowFitting: Barr. trif., disj. geral - DIN (4)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Número de polos: 70; Padrão das proteções: DIN; Comprimento: 46.7 cm; Largura: 10 cm; Profundidade: 98 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Tensão: 220/127 V; DPS - Grupo: Dispositivo de proteção contra surto - DIN; DPS - Peça: 175 V - 8 kA; DPS - Quantidade: 4
Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - embutir a 1,50m do piso; Nome: Cap. 70 disj. unip. - In barr. 225A; Classe: Quadro distrib. chapa pintada - embutir; Tipo: Barr. trif., disj. geral - DIN; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Barr. trif., disj. geral - DIN
Pset_ElectricalDeviceCommon-Ponto1 - NumberOfPoles: 3
Pset_ElectricalDeviceCommon-Ponto2 - NumberOfPoles: 4
Pset_ElectricalDeviceCommon-Ponto3 - NumberOfPoles: 1
AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Dispositivo de proteção contra surto - 175 V - 8 KA: 4; Quadro distrib. chapa pintada - embutir - Barr. trif., disj. geral - DIN - Cap. 70 disj. unip. - In barr. 225A: 1
Name | In | Quadro Alimentador | Proteção - Grupo | Proteção - Peça | Pset_ElectricalDeviceCommon-Ponto1, NominalCurrent (A) | Pset_ElectricalDeviceCommon-Ponto2, NominalCurrent (A) | Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 10 A - 3 kA | Dispositivo de Proteção - Disjuntor bipolar termomagnético - 380 V/220 V - DIN - Curva B - 10 A - 4.5 kA | Dispositivo de Proteção - Disjuntor bipolar termomagnético - 380 V/220 V - DIN - Curva B - 25 A - 4.5 kA
QD1 | 02. Térreo | AL1 | Disjuntor tripolar termomagnético (380 V/220 V) - DIN | 100 A - 13 kA - C | 100 | 100 | 10 | 3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 3; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 20 A - 3 kA: 1; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 25 A - 3 kA: 1; Dispositivo de Proteção - Disjuntor bipolar termomagnético - 380 V/220 V - DIN - Curva B - 20 A - 4.5 kA: 6; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 100 A - 13 kA: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 100 A: 1
QD2 | 03. Pavimento Superior | AL1 (02. Térreo) | Disjuntor tripolar termomagnético - DIN | 90 A - 10 kA - C | 90 | 100 | 8 | 12 | 2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 16 A - 3 kA: 5; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 100 A: 1; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 90A - 10 kA: 1
QD3 | 04. Cobertura | AL1 (02. Térreo) | Disjuntor tripolar termomagnético - DIN | 63 A - 4,5 kA - C | 63 | 63 | 11 |  | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor bipolar termomagnético - 380 V/220 V - DIN - Curva B - 20 A - 4.5 kA: 5; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 63 A - 4,5 kA: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 63 A: 1
QD4 | 05. Pavimento Técnico | AL1 (02. Térreo) | Disjuntor tripolar termomagnético - DIN | 40 A - 4,5 kA - C | 40 | 40 | 2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 40 A - 4,5 kA: 1; Dispositivo de Proteção - Disjuntor tripolar termomagnético - 380 V/220 V - DIN - Curva C - 40 A - 4.5 kA: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 40 A: 1

# IfcFlowFitting: Bucha de redução longa
In: 04. Cobertura
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 40 mm - 50 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Bucha de redução longa; Nome: 40 mm - 50 mm; Classe: PVC Esgoto; Tipo: Bucha de redução longa; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Bucha de redução longa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1

# IfcFlowFitting: Cap (2)
Type - PredefinedType: EXIT
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Cap; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Cap; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Cap
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Cap - 100 mm: 1
Name | In
 | 03. Pavimento Superior
 | 04. Cobertura

# IfcFlowFitting: CurVar 45º (3)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: CurVar 45º; Nome: 40 mm; Classe: PVC Esgoto; Tipo: CurVar 45º; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: CurVar 45º
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - CurVar 45º - 40 mm: 1
Name | In
2 x  | 02. Térreo
 | 03. Pavimento Superior

# IfcFlowFitting: Curva 45 Longa para Esgoto Sanitário (6)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 Longa para Esgoto Sanitário; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45 Longa para Esgoto Sanitário
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Curva 45 longa - 50 mm
 | 02. Térreo | 100 mm | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 45 longa - 100 mm: 1
2 x  | 02. Térreo | 50mm | 1
2 x  | 03. Pavimento Superior | 50mm | 1
 | 04. Cobertura | 50mm | 1

# IfcFlowFitting: Curva 45 Longa para Esgoto Sanitário- desce (2)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 Longa para Esgoto Sanitário- desce; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário- desce; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45 Longa para Esgoto Sanitário- desce
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 45 longa - 100 mm: 1
Name | In
TQ-2 | 02. Térreo
TQ-1 | 04. Cobertura

# IfcFlowFitting: Curva 45 Longa para Esgoto Sanitário- sobe, CV-1
In: 01. Estacionamento
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 50mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 Longa para Esgoto Sanitário- sobe; Nome: 50mm; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário- sobe; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Curva 45 Longa para Esgoto Sanitário- sobe
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Curva 45 longa - 50 mm: 1

# IfcFlowFitting: Curva 45 longa Amanco (3)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 45 longa Amanco; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Curva 45 longa Amanco; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 45 longa Amanco
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa Amanco - 40 mm: 1
Name | In
 | 02. Térreo
2 x  | 04. Cobertura

# IfcFlowFitting: Curva 90 curta- coluna bolsa (2)
In: 01. Estacionamento
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 curta- coluna bolsa; Nome: 100 mm; Classe: PVC Esgoto; Tipo: Curva 90 curta- coluna bolsa; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Curva 90 curta- coluna bolsa
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Curva 90 curta - 100 mm: 1
Name
TQ-1
TQ-2

# IfcFlowFitting: Curva 90 soldável (61)
Type - PredefinedType: BEND
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Curva 90 soldável; Classe: PVC rígido soldável; Tipo: Curva 90 soldável
Pset_PipeFittingTypeCommon - Reference: Curva 90 soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Curva 90 soldável - 25 mm
AL-1 | 01. Estacionamento | 25 mm | Alimentação | 1
10 x  | 02. Térreo | 25 mm | Água fria | 1
 | 03. Pavimento Superior | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
15 x  | 03. Pavimento Superior | 25 mm | Água fria | 1
19 x  | 04. Cobertura | 25 mm | Água fria | 1
AF-1 | 04. Cobertura | 25 mm | Água fria | 1
 | 05. Pavimento Técnico | 50 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 50 mm: 1
4 x  | 05. Pavimento Técnico | 25 mm | Alimentação | 1
4 x  | 05. Pavimento Técnico | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
2 x  | 05. Pavimento Técnico | 25 mm | Água fria | 1
AF-1 | 05. Pavimento Técnico | 25 mm | Água fria | 1
AF-2 | 05. Pavimento Técnico | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva 90 soldável - 32 mm: 1
AL-1 | 05. Pavimento Técnico | 25 mm | Alimentação | 1

# IfcFlowFitting: Joelho 45
In: 04. Cobertura
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 40 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 45; Nome: 40 mm; Classe: PVC Esgoto; Tipo: Joelho 45; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Joelho 45
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 40 mm: 1

# IfcFlowFitting: Joelho 90 soldável (34)
Type - PredefinedType: BEND
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Joelho 90 soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Joelho 90 soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 25 mm: 1
Name | In
5 x  | 02. Térreo
13 x  | 03. Pavimento Superior
16 x  | 04. Cobertura

# IfcFlowFitting: Junção simples (16)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Junção simples; Classe: PVC Esgoto; Tipo: Junção simples; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Junção simples
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 100mm - 4" | PVC Esgoto - Anel de borracha - 50mm - 2" = PVC Esgoto - Junção simples - 100 mm - 50 mm
 | 02. Térreo | 100 mm - 50 mm | 1 | 1
4 x  | 03. Pavimento Superior | 100 mm - 50 mm | 1 | 1
4 x  | 03. Pavimento Superior | 100 mm- 100 mm | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
4 x  | 04. Cobertura | 100 mm - 50 mm | 1 | 1
3 x  | 04. Cobertura | 100 mm- 100 mm | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1

# IfcFlowFitting: Luva + Bucha de redução sold. longa
In: 05. Pavimento Técnico
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 50 mm - 32 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva + Bucha de redução sold. longa; Nome: 50 mm - 32 mm; Classe: PVC rígido soldável; Tipo: Luva + Bucha de redução sold. longa; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva + Bucha de redução sold. longa
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 32 mm: 1; PVC rígido soldável - Luva soldável - 50 mm: 1

# IfcFlowFitting: Luva de redução soldável (3)
Type - PredefinedType: TRANSITION
AltoQi_Builder - Indicação: 32 mm - 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva de redução soldável; Nome: 32 mm - 25 mm; Classe: PVC rígido soldável; Tipo: Luva de redução soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Luva de redução soldável
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva de redução soldável - 32 mm - 25 mm: 1
Name | In
 | 03. Pavimento Superior
 | 04. Cobertura
 | 05. Pavimento Técnico

# IfcFlowFitting: Luva soldável (6)
Type - PredefinedType: CONNECTOR
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Luva soldável; Classe: PVC rígido soldável; Tipo: Luva soldável
Pset_PipeFittingTypeCommon - Reference: Luva soldável
Name | In | Indicação = Nome | Rede | PVC rígido soldável - Luva soldável - 25 mm
AF-1 | 02. Térreo | 25 mm | Água fria | 1
AF-1 | 03. Pavimento Superior | 25 mm | Água fria | 1
AF-2 | 03. Pavimento Superior | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 32 mm: 1
AL-1 | 03. Pavimento Superior | 25 mm | Alimentação | 1
AF-2 | 04. Cobertura | 32 mm | Água fria | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Luva soldável - 32 mm: 1
AL-1 | 04. Cobertura | 25 mm | Alimentação | 1

# IfcFlowFitting: Pontos de comando (36)
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm
AltoQi_Builder-Ponto1 - Quantidade: 1; Requer aterramento: Não
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de comando; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Pontos de comando
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Posição | Tipo de ponto | Descrição | Nome | Circuito_1 | Comando_1 | Pavimento_do_circuito_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor simples - 1 tecla
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 2 - Iluminação da Sala de Manutenção + Banheiro Térreo | d | 02. Térreo | QD1 | 1
 | 02. Térreo | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 3 - Iluminação da Sala de Energia + Escada 1 + DML | Nenhum | 02. Térreo | QD1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 4 - Iluminação do Hall | f | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | Média | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 5 - Iluminação do Salão Principal | g | 02. Térreo | QD1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 6 - Iluminação da Entrada de Serviço + Escada 2 | h | 02. Térreo | QD1 | 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação da Sala de Energia + Escada 1 + DML | k | 02. Térreo | QD1 | 1
 | 02. Térreo | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 6 - Iluminação da Entrada de Serviço + Escada 2 | i | 02. Térreo | QD1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação da Sala de Energia + Escada 1 + DML | l | 02. Térreo | QD1 | 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 2 - Iluminação da Sala de Manutenção + Banheiro Térreo | m | 02. Térreo | QD1 | 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação da Área de Serviço + Jardim | a | 02. Térreo | QD1 | 1
 | 02. Térreo | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação da Área de Serviço + Jardim | b | 02. Térreo | QD1 | 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | h | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | j | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | i | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 5 - Iluminação da Escada 2 | a | 03. Pavimento Superior | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação da Sala | b | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 2 - Iluminação do Hall e da Escada 1 | c | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 2 - Iluminação do Hall e da Escada 1 | d | 03. Pavimento Superior | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
2 x  | 03. Pavimento Superior | Média | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 4 - Iluminação do Salão | e | 03. Pavimento Superior | QD2 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | f | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | g | 03. Pavimento Superior | QD2 | 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | l | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | Média | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 5 - Iluminação da Área Descoberta e Escada 2 | k | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
2 x  | 04. Cobertura | Média | Interruptor paralelo | Interruptor paralelo 1 tecla - 1,20m do piso | Interruptor paralelo - 1 tecla | 4 - Iluminação do Salão | e | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Interruptor paralelo - 1 tecla: 1
 | 04. Cobertura | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 2 - Iluminação do Hall e da Escada 1 | d | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 2 - Iluminação do Hall e da Escada 1 | c | 04. Cobertura | QD3 | 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação da Sala | b | 04. Cobertura | QD3 | 1
 | 04. Cobertura | Alta | Interruptor sensor de presença | Interruptor sensor de presença a 2,20m do piso | Sensor de presença | 5 - Iluminação da Área Descoberta e Escada 2 | a | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor autom. por presença - 220V - 1200W resistivo: 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | o | 04. Cobertura | QD3 | 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | n | 04. Cobertura | QD3 | 1
 | 04. Cobertura | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 3 - Iluminação dos Banheiros | m | 04. Cobertura | QD3 | 1
 | 05. Pavimento Técnico | Média | Interruptor simples | Interruptor simples 1 tecla - 1,20m do piso | Interruptor simples - 1 tecla | 1 - Iluminação | p | 05. Pavimento Técnico | QD4 | 1

# IfcFlowFitting: Pontos de força - Uso específico (50)
AltoQi_Builder - Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm
AltoQi_Builder-Ponto1 - Quantidade: 1; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso específico; Rede: Elétrica
Circuito - Comando_1: Nenhum
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso específico
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1
Name | In | Indicação | Posição | Fator de potência (%) | Potência (W) | Rendimento (%) | Tipo de ponto | Descrição | Nome | Circuito_1 | Pavimento_do_circuito_1 | Quadro_1 | Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo
3 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 18 - Ar Condicionado Sala | 02. Térreo | QD1 | 1
 | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 19 - Ar Condicionado Sala de Energia | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 20 - Ar Condicionado Hall | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 25 - Ar Condicionado 9 e 10 Salão | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 24 - Ar Condicionado 7 e 8 Salão | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 23 - Ar Condicionado 5 e 6 Salão | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 22 - Ar Condicionado 3 e 4 Salão | 02. Térreo | QD1 | 1
2 x  | 02. Térreo | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 21 - Ar Condicionado 1 e 2 Salão | 02. Térreo | QD1 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 23 - Ar Condicionado 10 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 21 - Ar Condicionado 8 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 19 - Ar Condicionado 6 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 25 - Ar Condicionado 12 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 24 - Ar Condicionado 11 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 22 - Ar Condicionado 9 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 20 - Ar Condicionado 7 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 18 - Ar Condicionado 5 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 17 - Ar Condicionado 4 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 16 - Ar Condicionado 3 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 15 - Ar Condicionado 2 | 03. Pavimento Superior | QD2 | 1
 | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 14 - Ar Condicionado 1 | 03. Pavimento Superior | QD2 | 1
3 x  | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 36 - Ar Condicionado da Sala | 03. Pavimento Superior | QD2 | 1
3 x  | 03. Pavimento Superior | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 37 - Ar Condicionado do Hall | 03. Pavimento Superior | QD2 | 1
 | 04. Cobertura | MOO | Média | 90 | 620 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | Microondas | 9 - Tomadas da Despensa e Cozinha | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | 04. Cobertura | GEL | Baixa | 90 | 140 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 0,30m do piso | Geladeira | 9 - Tomadas da Despensa e Cozinha | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
3 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 12 - Ar Condicionado da Sala | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 13 - Ar Condicionado do Hall | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 14 - Ar Condicionado da Circulação | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 15 - Ar Condicionado do Salão 1 e 2 | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 16 - Ar Condicionado do Salão 3 e 4 | 04. Cobertura | QD3 | 1
2 x  | 04. Cobertura | ARC18000 | Alta | 90 | 1630 | 100 | Tomada 2P+T | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | Condicionador de ar Split 18000BTU | 17 - Ar Condicionado do Salão 5 e 6 | 04. Cobertura | QD3 | 1
 | 05. Pavimento Técnico | 10cv | Baixa | 82 | 9200 | 89 | Tomada 3P+T | Ponto para motor trifásico a 0,30m do piso | Elevador | 2 - Elevador | 05. Pavimento Técnico | QD4 | 1

# IfcFlowFitting: Pontos de força - Uso geral (162)
AltoQi_Builder - Comprimento: 7 cm
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T; Requer aterramento: Sim
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso geral; Rede: Elétrica
Circuito - Comando_1: Nenhum
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso geral
Name | In | Largura (cm) | Profundidade (cm) | Posição | Potência (W) | Quantidade | Descrição | Nome | Circuito_1 | Pavimento_do_circuito_1 | Quadro_1 | Acessórios p/ eletrodutos - Caixa PVC - 4x2"
2 x  | 02. Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 12 - Tomadas DML | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 12 - Tomadas DML | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 10 - Tomadas 110V Sala de Energia | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 11 - Tomadas 220V Sala de Energia | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 10 - Tomadas 110V Sala de Energia | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 8 - Tomadas 110V Manutenção + Banheiro | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 9 - Tomadas 220V Manutenção | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 8 - Tomadas 110V Manutenção + Banheiro | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 7 - Tomadas Área de Serviço | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 13 - Tomadas Hall | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 13 - Tomadas Hall | 02. Térreo | QD1 | 1 | Circuito - Circuito_2: 13 - Tomadas Hall; Comando_2: Nenhum; Pavimento_do_circuito_2: 02. Térreo; Quadro_2: QD1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
13 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 14 - Tomadas Parede de Divisa Salão | 02. Térreo | QD1 | 1 | Circuito - Circuito_2: 14 - Tomadas Parede de Divisa Salão; Comando_2: Nenhum; Pavimento_do_circuito_2: 02. Térreo; Quadro_2: QD1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
10 x  | 02. Térreo | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 15 - Tomadas Parede da Frente Salão | 02. Térreo | QD1 | 1 | Circuito - Circuito_2: 15 - Tomadas Parede da Frente Salão; Comando_2: Nenhum; Pavimento_do_circuito_2: 02. Térreo; Quadro_2: QD1; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
12 x  | 02. Térreo | 10.85 | 4.75 | Piso | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 16 - Grupo de 12 Tomadas do Piso do Salão (Esquerda) | 02. Térreo | QD1 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
12 x  | 02. Térreo | 10.85 | 4.75 | Piso | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 17 - Grupo de 12 Tomadas do Piso Salão (Direita) | 02. Térreo | QD1 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 02. Térreo | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | 2P+T 20 A - alta | 13 - Tomadas Hall | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
 | 02. Térreo | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 2,20m do piso | 2P+T 20 A - alta | 14 - Tomadas Parede de Divisa Salão | 02. Térreo | QD1 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
5 x  | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 7 - Tomadas do Hall e da Escada 1 | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
6 x  | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 13 - Tomadas da Parede da Frente e da Escada 2 | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 8 - Tomadas dos Banheiros | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
12 x  | 03. Pavimento Superior | 10.85 | 4.75 | Piso | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 12 - 14 unidades de Tomadas do Piso (Direita) | 03. Pavimento Superior | QD2 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
14 x  | 03. Pavimento Superior | 10.85 | 4.75 | Piso | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 11 - 14 unidades de Tomadas do Piso (Esquerda) | 03. Pavimento Superior | QD2 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 03. Pavimento Superior | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - alta | 7 - Tomadas do Hall e da Escada 1 | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
8 x  | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 10 - Tomadas da Parede de Divisa do Salão (8 da direita) | 03. Pavimento Superior | QD2 | 1 | Circuito - Circuito_2: 10 - Tomadas da Parede de Divisa do Salão (8 da direita); Comando_2: Nenhum; Pavimento_do_circuito_2: 03. Pavimento Superior; Quadro_2: QD2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
8 x  | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 9 - Tomadas da Parede de Divisa do Salão (8 da esquerda) | 03. Pavimento Superior | QD2 | 1 | Circuito - Circuito_2: 9 - Tomadas da Parede de Divisa do Salão (8 da esquerda); Comando_2: Nenhum; Pavimento_do_circuito_2: 03. Pavimento Superior; Quadro_2: QD2; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
4 x  | 03. Pavimento Superior | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 8 - Tomadas dos Banheiros | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
8 x  | 03. Pavimento Superior | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 6 - Tomadas da Sala | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 03. Pavimento Superior | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - alta | 13 - Tomadas da Parede da Frente e da Escada 2 | 03. Pavimento Superior | QD2 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
8 x  | 04. Cobertura | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 6 - Tomadas da Sala | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 04. Cobertura | 4.75 | 10.85 | Alta | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 2,20m do piso | 2P+T 10 A - alta | 7 - Tomadas do Hall e da Escada 1 | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
3 x  | 04. Cobertura | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - média | 8 - Tomadas dos Banheiros | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 04. Cobertura | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 9 - Tomadas da Despensa e Cozinha | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
2 x  | 04. Cobertura | 4.75 | 10.85 | Baixa | 100 | 2 | 2 Tomadas hexagonais (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10A (2) - baixa | 11 - Tomadas da Parede do Salão | 04. Cobertura | QD3 | 1 | Circuito - Circuito_2: 11 - Tomadas da Parede do Salão; Comando_2: Nenhum; Pavimento_do_circuito_2: 04. Cobertura; Quadro_2: QD3; AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 2 funções: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2 - 2P+T 10A: 1
4 x  | 04. Cobertura | 10.85 | 4.75 | Piso | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A no piso | 2P+T 10 A - piso | 10 - Tomadas do Piso do Salão | 04. Cobertura | QD3 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa alumínio 4"x2" - 3x4": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 04. Cobertura | 4.75 | 10.85 | Média | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 20 A a 1,20m do piso | 2P+T 20 A - média | 9 - Tomadas da Despensa e Cozinha | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 20A: 1
5 x  | 04. Cobertura | 4.75 | 10.85 | Baixa | 100 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 0,30m do piso | 2P+T 10 A - baixa | 7 - Tomadas do Hall e da Escada 1 | 04. Cobertura | QD3 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 05. Pavimento Técnico | 4.75 | 10.85 | Média | 200 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - 200 W - média | 4 - Tomada 127V | 05. Pavimento Técnico | QD4 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
 | 05. Pavimento Técnico | 4.75 | 10.85 | Média | 1000 | 1 | Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,20m do piso | 2P+T 10 A - 1000 W - média | 3 - Tomada 220V | 05. Pavimento Técnico | QD4 | 1 | AltoQi_QiBuilder-Itens_Associados - Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1

# IfcFlowFitting: Ramais de Ventilação
In: 01. Estacionamento
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 100mm - 50mm-135°; Posição: Direta
Identificação_Elemento - Aplicação: Ramal de ventilação; Descrição: Ramais de ventilação; Nome: 100mm - 50mm-135°; Classe: PVC Esgoto; Tipo: Ramais de Ventilação; Rede: Ventilação
Pset_PipeFittingTypeCommon - Reference: Ramais de Ventilação
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 1; PVC Esgoto - Anel de borracha - 50mm - 2": 2; PVC Esgoto - Joelho 90 - 50 mm: 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1

# IfcFlowFitting: Te 90 soldável (31)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Classe: PVC rígido soldável; Tipo: Te 90 soldável; Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável
Name | In | Indicação = Nome | PVC rígido soldável - Tê 90 soldável - 25 mm
5 x  | 02. Térreo | 25 mm | 1
8 x  | 03. Pavimento Superior | 25 mm | 1
17 x  | 04. Cobertura | 25 mm | 1
 | 04. Cobertura | 32 mm | AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 32 mm: 1

# IfcFlowFitting: Te 90 soldável (centro) (4)
In: 03. Pavimento Superior
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 25 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te 90 soldável; Nome: 25 mm; Classe: PVC rígido soldável; Tipo: Te 90 soldável (centro); Rede: Água fria
Pset_PipeFittingTypeCommon - Reference: Te 90 soldável (centro)
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 25 mm: 1

# IfcFlowFitting: Te de inspeção com Plug - Vertical (4)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te de inspeção com Plug; Classe: PVC Esgoto; Tipo: Te de inspeção com Plug - Vertical
Pset_PipeFittingTypeCommon - Reference: Te de inspeção com Plug - Vertical
Name | In | Indicação = Nome | Rede | PVC Esgoto - Anel de borracha - 50mm - 2" | PVC Esgoto - Plug - 50 mm = PVC Esgoto - Tê sanitário - 50 mm - 50 mm
CV-1 | 02. Térreo | 50 mm - 50 mm | Ventilação | 2 | 1
TQ-1 | 02. Térreo | 100 mm - 100 mm | Esgoto | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Plug - 100 mm: 1; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1
CV-1 | 03. Pavimento Superior | 50 mm - 50 mm | Ventilação | 2 | 1
CV-1 | 04. Cobertura | 50 mm - 50 mm | Ventilação | 2 | 1

# IfcFlowFitting: Te sanitário (4)
Type - PredefinedType: JUNCTION
AltoQi_Builder - Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário; Classe: PVC Esgoto; Tipo: Te sanitário; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Te sanitário
Name | In | Indicação = Nome | PVC Esgoto - Anel de borracha - 100mm - 4"
 | 02. Térreo | 100 mm - 50 mm | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
2 x  | 04. Cobertura | 100 mm - 100 mm | 2 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1
 | 04. Cobertura | 100 mm - 50 mm | 1 | AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 50mm - 2": 1; PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1

# IfcFlowFitting: Te sanitário- coluna, TQ-1
In: 03. Pavimento Superior
Type - PredefinedType: JUNCTION
AltoQi_Builder - Indicação: 100 mm - 100 mm; Posição: Direta
Identificação_Elemento - Aplicação: Conexão; Descrição: Te sanitário- coluna; Nome: 100 mm - 100 mm; Classe: PVC Esgoto; Tipo: Te sanitário- coluna; Rede: Esgoto
Pset_PipeFittingTypeCommon - Reference: Te sanitário- coluna
AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Anel de borracha - 100mm - 4": 2; PVC Esgoto - Tê sanitário - 100 mm - 100 mm: 1

# IfcFlowFitting: Torneira bóia
In: 05. Pavimento Técnico
Type - PredefinedType: ENTRY
AltoQi_Builder - Indicação: 3/4"; Posição: Direta
Identificação_Elemento - Aplicação: Tomada d´água; Descrição: Torneira de bóia; Nome: 3/4"; Classe: PVC rígido soldável; Tipo: Torneira bóia; Rede: Alimentação
Pset_PipeFittingTypeCommon - Reference: Torneira bóia
AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Adapt sold. c/ flange livre p/ cx. d´água - 25 mm - 3/4": 1; PVC rígido soldável - Torneira de bóia - 3/4": 1

# IfcFlowSegment: Eletroduto tipo leve (369)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo leve; Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo leve
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm)
El100 | 02. Térreo | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 230 cm
El101 | 02. Térreo | 1.94 | ø3/4" | 0.15 | 60 | 3/4" | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 60 cm
El102 | 02. Térreo | 1.94 | ø3/4" | 0.15 | 565 | 3/4" | 1130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Preto: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Verde-amarelo: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 565 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Preto: 565 cm
