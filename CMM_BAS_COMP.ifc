Properties of the parts of a building model (IFC2X3), part 4 of 6

# IfcFlowSegment: Eletroduto tipo leve (369)
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto leve - 3/4" (cm)
El92 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 300 | 3/4" | 600 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 600 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 300 cm
El93 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 300 | 3/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 300 cm
El94 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 300 | 3/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 300 cm
El95 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 300 | 3/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 300 cm
El96 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 300 | 3/4" | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 300 cm
El97 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm
El98 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 150 cm
El99 | 03. Pavimento Superior | 1.94 | ø3/4" | 0.15 | 375 | 3/4" | 375 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 375 cm
El171 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 790 | 3/4" | 790 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 2370 cm
El172 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 1047.2 | 3/4" | 1047.2 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 1047.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1047.2 cm
El173 | 04. Cobertura | 2.56 | ø1" | 0.32 | 1197.2 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 4788.8 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1197.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 4788.8 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 1197.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 1197.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 2394.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 2394.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 1197.2 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 3591.6 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 2394.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 1197.2 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 2394.4 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 1197.2 cm
El174 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 377.63 | 3/4" | 377.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 755.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 377.625 cm
El175 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 587.63 | 3/4" | 587.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 587.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 1175.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 587.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 587.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 587.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 587.625 cm
El176 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 607.63 | 3/4" | 607.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 607.625 cm
El177 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 220 cm
El178 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 260 cm
El179 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 340 | 3/4" | 340 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 340 cm
El180 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 150 cm
El181 | 04. Cobertura | 2.56 | ø1" | 0.32 | 190 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 190 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 570 cm
El182 | 04. Cobertura | 2.56 | ø1" | 0.32 | 150 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 150 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 450 cm
El183 | 04. Cobertura | 2.56 | ø1" | 0.32 | 170 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 170 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 510 cm
El184 | 04. Cobertura | 2.56 | ø1" | 0.32 | 180 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 540 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 180 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 360 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 540 cm
El185 | 04. Cobertura | 2.56 | ø1" | 0.32 | 250 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 750 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 750 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 250 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 750 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 250 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 750 cm
El186 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 150 cm
El187 | 04. Cobertura | 2.56 | ø1" | 0.32 | 340 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 340 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 1020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 340 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 680 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 1020 cm
El188 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El189 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 660 cm
El190 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El191 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 660 cm
El192 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El193 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 660 cm
El194 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El195 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 660 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 220 cm
El196 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 450 cm
El197 | 04. Cobertura | 2.56 | ø1" | 0.32 | 1335 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 2670 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1335 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 1335 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 1335 cm
El198 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 610 | 3/4" | 610 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 1830 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 610 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 610 cm
El199 | 04. Cobertura | 2.56 | ø1" | 0.32 | 1000 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1000 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 1000 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 1000 cm
El200 | 04. Cobertura | 2.56 | ø1" | 0.32 | 160 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 160 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 160 cm
El201 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 230 cm
El202 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 460 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 230 cm
El203 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 230 | 3/4" | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 230 cm
El204 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 190 | 3/4" | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 570 cm
El205 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 220 cm
El206 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 220 cm
El207 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 220 cm
El208 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 220 | 3/4" | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 220 cm
El209 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El210 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El211 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El212 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El213 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 150 | 3/4" | 150 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 150 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 150 cm
El214 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 140 cm
El215 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 180 | 3/4" | 180 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 180 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 180 cm
El216 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 170 cm
El217 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 275 | 3/4" | 275 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 275 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 275 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 275 cm
El218 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 370 | 3/4" | 370 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 370 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 370 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 370 cm
El219 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 700 | 3/4" | 700 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 700 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 700 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 700 cm
El220 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 285 | 3/4" | 285 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 285 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 285 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 285 cm
El221 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 80 cm
El222 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 90 | 3/4" | 90 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 90 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 90 cm
El223 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 285 | 3/4" | 285 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 570 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 285 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 285 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 285 cm
El224 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 260 cm
El225 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 425 | 3/4" | 425 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 425 cm
El226 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 440 | 3/4" | 440 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 440 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 440 cm
El227 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 320 | 3/4" | 320 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 320 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 320 cm
El228 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 450 | 3/4" | 450 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 450 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 450 cm
El229 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 130 | 3/4" | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 130 cm
El230 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 130 | 3/4" | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 130 cm
El231 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 140 | 3/4" | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 140 cm
El232 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 430 | 3/4" | 430 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 430 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Branco: 430 cm
El233 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 260 cm
El234 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 260 cm
El235 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Verde-amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Preto: 260 cm
El236 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 415 | 3/4" | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 415 cm
El237 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 80 | 3/4" | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 80 cm
El238 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 240 | 3/4" | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 240 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 240 cm
El239 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 425 | 3/4" | 425 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 425 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 425 cm
El240 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 200 cm
El241 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 200 | 3/4" | 200 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 200 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 200 cm
El242 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 355 | 3/4" | 355 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 710 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 355 cm
El243 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 285 | 3/4" | 285 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 855 cm
El244 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 315 | 3/4" | 315 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 315 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 315 cm
El245 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 295 | 3/4" | 295 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 295 cm
El246 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 295 | 3/4" | 295 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 295 cm
El247 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 295 | 3/4" | 295 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 295 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 295 cm
El248 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 345 | 3/4" | 345 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 345 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 345 cm
El249 | 04. Cobertura | 1.94 | ø3/4" | 0.15 | 805 | 3/4" | 805 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 805 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Amarelo: 1610 cm
El10 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 415 | 3/4" | 415 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 415 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 415 cm
El11 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 170 | 3/4" | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 170 cm
El12 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 100 | 3/4" | 100 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 100 cm
El13 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 235 | 3/4" | 235 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 235 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 235 cm
El14 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 70 | 3/4" | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 70 cm
El15 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 380 | 3/4" | 380 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 380 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 380 cm
El3 | 05. Pavimento Técnico | 2.56 | ø1" | 0.32 | 962.38 | 1" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Preto: 962.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Verde-amarelo: 962.375 cm; Eletroduto PVC flexível - Eletroduto leve - 1": 962.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Vermelho: 962.375 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Branco: 962.375 cm
El4 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 407.63 | 3/4" | 407.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 407.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 407.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 407.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 407.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Vermelho: 407.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Preto: 407.625 cm
El5 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 377.63 | 3/4" | 377.625 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 377.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 377.625 cm
El6 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 260 cm
El8 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 350 | 3/4" | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 350 cm
El9 | 05. Pavimento Técnico | 1.94 | ø3/4" | 0.15 | 260 | 3/4" | 260 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 260 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 260 cm

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (135)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado (PEAD); Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo pesado (PEAD)
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | In | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto pesado - 1.1/4" (cm)
El10 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 180 | 1.1/4" | 180
El11 | 02. Térreo | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 240 | 1.1/4" | 240 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 240 cm
El164 | 02. Térreo | 5 | ø2" | 0.63 | ø2" | 190 | 2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 190 cm; Eletroduto PVC flexível - Eletroduto pesado - 2": 380 cm
El165 | 02. Térreo | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 187.63 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 187.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 187.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 187.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 187.625 cm; Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 375.25 cm
El166 | 02. Térreo | 8 | ø3" | 0.7 | ø3" | 480 | 3" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 480 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 960 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 960 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 960 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 960 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 960 cm
5 x El167 | 02. Térreo | 8 | ø3" | 0.7 | ø3" | 1510 | 3" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 1510 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 3020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 3020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 3020 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 3020 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 3020 cm
El167 | 02. Térreo | 8 | ø3" | 0.7 | ø3" | 885 | 3" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Azul claro: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Branco: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Preto: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 25 mm² - Vermelho: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Azul claro: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Branco: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Preto: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 50 mm² - Vermelho: 885 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Azul claro: 1770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Branco: 1770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Preto: 1770 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 70 mm² - Vermelho: 1770 cm; Eletroduto PVC flexível - Eletroduto pesado - 3": 1770 cm
El171 | 02. Térreo | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 797.63 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/2": 1595.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1595.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Preto: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Azul claro: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 10 mm² - Preto: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Azul claro: 1595.25 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Branco: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Preto: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 16 mm² - Verde-amarelo: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Azul claro: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 4 mm² - Vermelho: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Azul claro: 797.625 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Branco: 3988.12 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Preto: 2392.88 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Vermelho: 3988.12 cm
